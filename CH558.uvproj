# Keil uVision project CH558.uvproj, settings and files
target SimPad v3 Firmware (MCS-51)
  device: CH558 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FFF)  IROM(0-0x3FFF) CLOCK(56000000)
  output: SIMPAD_V3_FIRMWARE +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\SimPad_v3
  group Source
    ./SIMPAD_V3/: SIMPAD_CORE.C
    ./CORE_LIB/: DEBUG.C CHIP_ID.C
    ./KEYBOARD/: KEYBOARD.C
    ./DATAFLASH/: DATAFLASH.C
    ./USB_MODULE/: USB_CORE.C
    ./RGB_LIB/: RGB_LIB_APA102C.C RGB_LIB.C
